Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-20T11:14:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 20 11:14:06 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{9F83AB4C-D78A-4FEA-8884-1A50C19E1421}\ifc * Database version: 5507 * Database creation date: Wed Mar 20 11:14:06 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 20 11:14:06 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 20 11:14:06 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3907F Washbasin faucet, 3907F(2016):3907F Washbasin faucet:312914
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 187.1 mm; NominalHeight: 250.6 mm; NominalWidth: 103.381 mm; Projection: 152 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3907F(2016); ConvergoRefNr: 0087-1803-0028-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 14/03/2019
Type - Green Building Properties(Type) - Approval KIWA SE Type Approval: 1413; Customs Code: 84818011; EAN Number: 6414150078279; EN Standard: EN 817; NRF Number: 4200183; RSK Number: 8277661; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/3907F; VVS Number: 701242504
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3907F; Catalog Drawing URL: http://static.oras.com/catdrw/3907F; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/3907F; FDV Document URL: http://www.oras.com/datasheet/3907F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3907F; Group: Washbasin faucet; Long Marketing: Washbasin faucet with high swivel spout. There are also in-built limitation options for water temperature and maximum flow-rate. Flow controller 6.0 l/min. F= with flexible pipes; Manufacturer: Oras; Market: INT;NOR;SWE;DNK;POL;RUS;EST;LVA;UKR;LTU; Model: 3907F Washbasin faucet; Name_en: 3907F Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 407 x 265 x 119; Package Weight: 1.917 kg; Product Code: 3907F; Product Datasheet: http://www.oras.com/datasheet/3907F; Product Family: Oras Saga; Product Image URL: http://static.oras.com/image/3907F; Product URL: http://static.oras.com/3907F; Type Name: 3907F Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/8; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.oras.com/manual/3907F; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Noise Class: I (ISO 3822) Oras lab.; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 200000 Pa; Spare Parts: http://static.oras.com/sp/3907F; Spout Swivel Range: 120° (360°); Spout Type: Swivel spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3907F(2016); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3907F; Name: 3907F Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 105x190x250 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3907F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3907F Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0932246 m2; Volume: 0.00485105 m3
Identity Data - Mark: 3
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3907F(2016): 3907F Washbasin faucet; Family and Type: 3907F(2016): 3907F Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3907F(2016): 3907F Washbasin faucet; Type Id: 3907F(2016): 3907F Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
